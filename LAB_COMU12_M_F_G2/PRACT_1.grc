options:
  parameters:
    generate_options: qt_gui
    id: PRACT_1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Gain
    start: '0'
    step: '1'
    stop: '30'
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: FC
    start: 87.5E6
    step: '1'
    stop: 108E6
    value: 100E6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '12500'
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    label: Bw
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: promedios_de_tiempos
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """
      import numpy as np
      from gnuradio import gr
      class blk (gr.sync_block ):
        def __init__ ( self ) : # only default arguments here
            gr.sync_block.__init__ (
                self ,
                name ='Promedios_de_tiempos', # will show up in GRC
                in_sig =[ np.float32 ],
                out_sig =[ np.float32,np.float32,np.float32,np.float32,np.float32 ]
            )
            self.acum_anterior = 0
            self.Ntotales = 0
            self.acum_anterior1 = 0
            self.acum_anterior2 = 0
        def work (self,input_items,output_items):
            x = input_items [0] # Senial de entrada .
            y0 = output_items [0] # Promedio de la senial
            y1 = output_items [1] # Media de la senial
            y2 = output_items [2] # RMS de la senial
            y3 = output_items [3] # Potencia promedio de la senial
            y4 = output_items [4] # Desviacion estandar de la senial

            # Calculo del promedio
            N = len (x)
            self.Ntotales = self.Ntotales + N
            acumulado = self.acum_anterior + np.cumsum(x)
            self.acum_anterior = acumulado [N-1]
            y0 [:]= acumulado/self.Ntotales

            # Calculo de la media cuadratica
            x2=np.multiply (x,x)
            acumulado1 = self.acum_anterior1 + np.cumsum(x2)
            self.acum_anterior1 = acumulado1[N-1]
            y1 [:] = acumulado1/self.Ntotales

            # Calculo de la RMS
            y2 [:] = np.sqrt (y1)
            # Calculo de la potencia promedio
            y3 [:] = np.multiply(y2,y2)

            # Calculo de la desviacion estandar
            x3 = np.multiply (x-y0,x-y0)
            acumulado2 = self.acum_anterior2 + np.cumsum(x3)
            self.acum_anterior2 = acumulado2 [N-1]
            y4 [:] = np.sqrt (acumulado2/self.Ntotales)
            return len (x)
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"PROMEDIO"'
    type: float
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"MEDIA"'
    type: float
  states: {}
- name: qtgui_number_sink_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"RMS"'
    type: float
  states: {}
- name: qtgui_number_sink_3
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"POTENCIA_PROMEDIO"'
    type: float
  states: {}
- name: qtgui_number_sink_4
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"DESVIACION_STANDARD"'
    type: float
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX1"'
    center_freq0: fc
    gain0: GTX
    otw: sc16
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', promedios_de_tiempos, '0']
- [promedios_de_tiempos, '0', qtgui_number_sink_0, '0']
- [promedios_de_tiempos, '1', qtgui_number_sink_1, '0']
- [promedios_de_tiempos, '2', qtgui_number_sink_2, '0']
- [promedios_de_tiempos, '3', qtgui_number_sink_3, '0']
- [promedios_de_tiempos, '4', qtgui_number_sink_4, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
