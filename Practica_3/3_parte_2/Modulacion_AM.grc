options:
  parameters:
    author: Elian_Rojas_J1B_G6
    copyright: UIS
    generate_options: qt_gui
    id: ModulacionAM
    output_language: python
    title: Modulador de amplitud
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: amplitud de portadora
    start: '0'
    step: '1e-3'
    stop: '1'
    value: '125e-3'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: amplitud mensaje
    start: '0'
    step: '100e-3'
    stop: '4'
    value: '1'
  states: {}
- name: B
  id: variable_qtgui_range
  parameters:
    label: Cambio de banda
    start: '-1'
    step: '2'
    stop: '1'
    value: '1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: ganancia del transmisor
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: K
  id: variable_qtgui_range
  parameters:
    label: Al
    start: '0'
    step: '1'
    stop: '1'
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de portadora
    start: 50e6
    step: 1e6
    stop: 2.2e9
    value: 50e6
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: frecuencia del mensaje
    start: '300'
    step: '100'
    stop: 1e6
    value: '10000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 12500000/16
  states: {}
- name: SSB_0
  id: SSB
  parameters:
    Ac: Ac
    B: B
    K: K
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [SSB_0, '0', qtgui_freq_sink_x_0, '0']
- [SSB_0, '0', qtgui_time_sink_x_0, '0']
- [SSB_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', SSB_0, '0']

metadata:
  file_format: 1
